//#include <stdio.h>
static unsigned r0, r1, r2, r3, r4, r5, r15;
int main()
{
	r0 = 0;
	r1 = 0;
	r2 = 3;
	r3 = 4;
	r4 = 7;
	while (1)
	{
		r0++;
		//////////////////////////////
		r15 = r2 << 1;
		if (r15 >= 1)
		{
		//////////////////////////////
		r15 = r2 + 9;
		if (r15 == 12)
		{
		//////////////////////////////
		r15 = r2 * 4;
		if (r15 == 12)
		{
		//////////////////////////////
		r15 = r3 ^ r2;
		if (r15 <= 10)
		{
		//////////////////////////////
		r15 = r3 - r2;
		if (r15 == 1)
		{
		//////////////////////////////
		r15 = r4 & r2;
		if (r15 > 0)
		{
		//////////////////////////////
		r15 = r4 | r2;
		if (r15 == r4)
		{
		//////////////////////////////
		r15 = r4 >> 1;
		if (r15 < 7)
		{
			//////////////////////////////
			//printf("cont %h\n", r15);
			r1++;
		}
		}
		}
		}
		}
		}
		}
		}
		if (r0 != r1)
			break;
	}
}
